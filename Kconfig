## libloragw/Kconfig
```kconfig
#
# Copyright (c) 2020 Circuit Dojo
#
# SPDX-License-Identifier: Apache-2.0
#

menu "Semtech SX1302 HAL"

endmenu
```
